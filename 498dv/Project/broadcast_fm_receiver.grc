options:
  parameters:
    author: ben44496
    generate_options: qt_gui
    id: broadcast_fm_receiver
    output_language: python
    title: Broadcast FM receiver
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: interp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 88e6
    step: 200e3
    stop: 108e6
    value: 102.1e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '50e-3'
    stop: '1'
    value: '300e-3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: audio_decim
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: 192e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: rf_decim
    interp: '1'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: AB
    bw0: 500e3
    center_freq0: tuning
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
